# Repository ibnAbdelkader/AudioAmplifier

File README.md:

# AudioAmplifier
Simple Audio Amplifier/Detector PCB design using KiCad8.

## KiCad design soundAmplifierCircuit.kicad_pcb

Board: 2 copper layers, 39.0 x 43.0 mm, 22 parts (0 on the bottom side), 14 nets.

Parts:
+POWER-: TerminalBlock_4Ucon_1x02_P3.50mm_Vertical
ANAOUT: PinHeader_1x02_P2.54mm_Vertical
C1, C4: 100n; C_Rect_L4.6mm_W3.0mm_P2.50mm_MKS02_FKP02
C2: 200n; C_Rect_L4.6mm_W3.0mm_P2.50mm_MKS02_FKP02
C3: 10u; CP_Radial_D5.0mm_P2.50mm
C5: 33u; CP_Radial_D5.0mm_P2.50mm
C6: 470u; CP_Radial_D8.0mm_P3.80mm
C7: 4.7u; CP_Radial_D5.0mm_P2.50mm
CON_DIGIOUT: PinHeader_1x02_P2.54mm_Vertical
DIGIOUT: TerminalBlock_4Ucon_1x02_P3.50mm_Vertical
INPUT: PinHeader_1x02_P2.54mm_Vertical
MIC: POM-2244P-C3310-2-R
Q1: PN2222A; TO-92_Inline
R1, R4, R5: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2, R3: 10; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RV1: 10k; Potentiometer_Piher_PT-6-V_Vertical
RV2: 1k; Potentiometer_Piher_PT-6-V_Vertical
U1: LM386; DIP-8_W7.62mm

Connections:
+5V: +POWER-.1, C4.2, C5.1, R1.1, R5.2, U1.6 (V+)
GND: +POWER-.2, ANAOUT.2, C4.1, C5.2, C7.2, DIGIOUT.2, INPUT.1, MIC.1 (-), R2.2, R3.2, RV1.3, RV2.2, U1.2 (-), U1.4 (GND)
unnamed: ANAOUT.1, C6.2, CON_DIGIOUT.1
unnamed: C1.2, RV1.1
unnamed: C2.1, R2.1
unnamed: C2.2, C6.1, U1.5
unnamed: C3.1, U1.1 (GAIN)
unnamed: C3.2, U1.8 (GAIN)
unnamed: C7.1, DIGIOUT.1, Q1.3 (C), R5.1
unnamed: C1.1, INPUT.2, MIC.2 (+), R1.2
unnamed: CON_DIGIOUT.2, R3.1, R4.1
unnamed: Q1.2 (B), R4.2
unnamed: Q1.1 (E), RV2.1
unnamed: RV1.2, U1.3 (+)

## Commit log

2024-09-09 upload
